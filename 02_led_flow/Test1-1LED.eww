<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Tset1-1 LED.ewp</path>
  </project>
  <batchBuild/>
</workspace>


