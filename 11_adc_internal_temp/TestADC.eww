<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TestADC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\TestADC2\TestADC2.ewp</path>
  </project>
  <batchBuild/>
</workspace>


